# Keil uVision project YL_FreeRTOS.uvprojx, settings and files
target Target 1 (ARM-ADS)
  device: ARMCM3 ARM
  pack: ARM.CMSIS.4.3.0
  cpu: IROM(0x00000000,0x40000) IRAM(0x20000000,0x20000) CPUTYPE("Cortex-M3") CLOCK(12000000) ESEL ELITTLE
  output: YL_FreeRTOS
  c flags: Optim=1 OneElfS=1 uC99=1 wLevel=2
  c include: ..\User;..\freertos\include;..\freertos\protable\RVDS\ARM_CM3;..\freertos
  memory RVCT4: ROM 0x0 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x20000
  group User
    ../User/: main.c
  group FreeRTOS/ports
    ../freertos/protable/RVDS/ARM_CM3/: port.c
  group FreeRTOS/Source
    ../freertos/protable/RVDS/ARM_CM3/: task.c list.c
    ../freertos/include/: FreeRTOS.h FreeRTOSConfig.h list.h portable.h portmacro.h projdefs.h task.h
  group Doc
    ../Doc/: Readme.txt
software components: CMSIS:CORE 4.1.0, Device:Startup 1.0.1
